<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\022_UARTEchoInterrupt.ewp</path>
  </project>
  <batchBuild />
</workspace>
