<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\026_UARTReadLineDMACircularBuffer.ewp</path>
  </project>
  <batchBuild />
</workspace>
