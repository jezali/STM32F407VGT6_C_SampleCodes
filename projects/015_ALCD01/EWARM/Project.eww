<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\015_ALCD01.ewp</path>
  </project>
  <batchBuild />
</workspace>
